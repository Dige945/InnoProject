# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\beep;.\APP\touch_key;.\APP\lsens;.\APP\usart3;.\APP\hc05;.\APP\time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/lsens/: lsens.c
    ./APP/tftlcd/: tftlcd.c bk_image.c tftlcd.h bk_image.h
    ./APP/oled/: oled.c oled.h oledfont.h picture.h
    ./APP/beep/: beep.c beep.h music.c music.h
    ./APP/dht11/: dht11.c dht11.h
    ./APP/hwjs/: hwjs.c hwjs.h
    ./APP/key/: key.c key.h
    ./APP/pwm/: pwm.c pwm.h
    ./APP/rtc/: rtc.c rtc.h
    ./APP/ws2812/: ws2812.c ws2812.h rgb_display.c rgb_display.h
    ./APP/hc05/: hc05.c hc05.h
    ./APP/usart3/: usart3.c usart3.h
    ./APP/time/: time.c time.h
  group Public
    ./Public/: system.c SysTick.c usart.c
